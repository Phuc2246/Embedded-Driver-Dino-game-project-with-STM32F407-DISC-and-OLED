# Keil uVision project STM32F407_DEVELOPMENT.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407_DEVELOPMENT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\header
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: main.c stm32f407xx_gpio_driver.c cortexM4.c stm32f407xx_usart_driver.c stm32f407xx_timer_driver.c dino_game.c ssd1306.c stm32f407xx_i2c_driver.c
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
